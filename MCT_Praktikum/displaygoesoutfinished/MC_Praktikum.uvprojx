# Keil uVision project MC_Praktikum.uvprojx, settings and files
target Discocery Board - Flash (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MCPraktikum
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group C Sources
    ./: main.c _mcpr_stm32f407.c func.h fonts.h display.c display.h func.c timer.h timer.c
target Discovery Board - RAM (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: as above
  output: MCPraktikum
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: VECT_TAB_SRAM
  memory RVCT4: ROM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x20010000 size 0x10000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Objects\MCPraktikum.sct
target Simulation - Flash (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: as above
  output: MCPraktikum
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: HSI_VALUE=168000000
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 3.40.0, Device:Startup 2.6.2
